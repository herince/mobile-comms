options:
  parameters:
    author: akik
    generate_options: qt_gui
    id: USRPReceive
    output_language: python
    title: USRP receive
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 70e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sat_freq
  id: variable
  parameters:
    value: 436.238e6
  states: {}
- name: size
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_wfm_rcv_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    comment: |-
      Visualize max amplitude to measure its correlation
      with the USRP TX and RX gain
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: size
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: size
    vlen_out: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: size
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: size
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import uhd
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Apply LP filter to remove noise
    cutoff_freq: samp_rate / 4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate / 24
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency diagram of the raw signal to see all the noise
    fc: center_freq
    fftsize: '1024'
    name: '"Raw signal frequency domain graph"'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: '"FIltered signal"'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Real part"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Imaginary part"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Received signal time sink"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Data"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: '"FIltered signal"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: |-
      Waterfall diagram of the raw signal
      Bandwidth = USRP source sample rate
    fc: center_freq
    fftsize: '1024'
    name: '"Raw signal waterfall graph"'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    comment: |-
      Listen on -200kHz to fix lo leakage
      Gain value should be max or close to max (?)
    gain0: '60'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_float_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_float_0, '1', blocks_stream_to_vector_0_0, '0']
- [blocks_max_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_max_xx_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_max_xx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_max_xx_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_float_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
