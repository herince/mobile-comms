options:
  parameters:
    author: akik
    generate_options: qt_gui
    id: USRPTransmit
    output_language: python
    title: USRP transmit
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: sat_freq
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sat_freq
  id: variable
  parameters:
    value: 436.238e6
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import uhd
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_null_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
