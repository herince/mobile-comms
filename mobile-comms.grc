options:
  parameters:
    author: akik
    generate_options: qt_gui
    id: USRPReceive
    output_language: python
    title: USRP receive
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: sat_freq
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sat_freq
  id: variable
  parameters:
    value: 436.238e6
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate / 4
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    comment: Wideband FM Demodulation
    quad_rate: 5e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '"surround71:0"'
    ok_to_block: 'False'
    samp_rate: '44100'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: /home/ralitsa/akik/dsp/fm_record.wav
    format: FORMAT_WAV
    samp_rate: '500000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Test that the audio device sync works correctly
    file: /home/ralitsa/Downloads/StarWars3.wav
    repeat: 'True'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import uhd
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Apply LP filter to remove noise
    cutoff_freq: samp_rate / 250
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate / 500
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 4e3
    decim: '1'
    gain: '1'
    samp_rate: 441e2
    type: fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: Show constellation diagram to figure out the exact modulation scheme (?)
    grid: 'True'
    size: '10'
    type: complex
    update_time: '0.20'
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency diagram of the raw signal to see all the noise
    fc: center_freq
    fftsize: '1024'
    name: '"Raw signal frequency domain graph"'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency diagram of the filtered signal
    fc: center_freq
    fftsize: '1024'
    name: '"After the low pass filter"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: |-
      Waterfall diagram of the raw signal
      Bandwidth = USRP source sample rate
    fc: center_freq
    fftsize: '1024'
    name: '"Raw signal waterfall graph"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5000'
    interp: '441'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    clock_source0: gpsdo
    comment: |-
      Listen on -200kHz to fix lo leakage
      Gain value should be max or close to max (?)
    gain0: '60'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_wavfile_sink_0, '0']
- [analog_fm_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_1, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1, '0']
- [uhd_usrp_source_0, '0', blocks_null_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
